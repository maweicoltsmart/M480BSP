# IAR project LwIP_SSL_Server.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __TARGET_FPU_VFP; MBEDTLS_CONFIG_FILE=<ssl_config.h>
  ICCARM.CCDiagSuppress: Pa082,Pe550,Pe177,Pe549
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; ..; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F; ..\..\lwip\include; ..\..\..\..\ThirdParty\lwip\src\include\; ..\..\..\..\ThirdParty\mbedtls-2.13.0\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __TARGET_FPU_VFP
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\..\Library\Device\Nuvoton\M480\Include; $PROJ_DIR$..\..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\; $PROJ_DIR$..\..\..\Common\include
  OBJCOPY.OOCOutputFile: LwIP_SSL_Server.bin
  ILINK.IlinkOutputFile: LwIP_SSL_Server.out
  ILINK.IlinkIcfFile: LwIP_SSL_Server.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c crypto.c m480sys.c retarget.c uart.c
  group lwIP
    ../../../../ThirdParty/lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../ThirdParty/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../ThirdParty/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../ThirdParty/lwIP/src/netif/: ethernet.c
    ../../lwIP/netif/: ethernetif.c m480_eth.c
    ../../lwIP/: sys_arch.c time_stamp.c
  group mbedtls
    ../../../../ThirdParty/mbedtls-2.13.0/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group User
    ../: main.c net_sockets.c ssl_server.c
