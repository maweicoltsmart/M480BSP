# IAR project LwIP_TCP_EchoServer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __TARGET_FPU_VFP; MBEDTLS_CONFIG_FILE=<ssl_config.h>
  ICCARM.CCDiagSuppress: Pa082,Pe550,Pe177,Pe549
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; ..; ..\..\lwIP\include\netif; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\IAR\ARM_CM4F; ..\..\lwip\include; ..\..\..\..\ThirdParty\lwip-2.1.2\src\apps\http; ..\..\..\..\ThirdParty\lwip-2.1.2\src\include\; ..\..\..\..\ThirdParty\mbedtls-2.13.0\include; ..\..\..\..\ThirdParty\cJSON\; ..\..\..\..\ThirdParty\CmBacktrace\cm_backtrace\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: RVDS_ARMCM4_NUC4xx; __TARGET_FPU_VFP
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\..\Library\Device\Nuvoton\M480\Include; $PROJ_DIR$..\..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\; $PROJ_DIR$..\..\..\Common\include
  OBJCOPY.OOCOutputFile: LwIP_TCP_EchoServer.bin
  ILINK.IlinkOutputFile: LwIP_TCP_EchoServer.out
  ILINK.IlinkIcfFile: D:\自主研发产品\DTU\ETH DTU\M487\M480BSP\SampleCode\NuMaker-PFM-M487\LwIP_TCP_EchoServer\IAR\LwIP_TCP_EchoServer.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: croutine.c event_groups.c list.c ostimers.c queue.c stream_buffer.c tasks.c
  group FreeRTOS/Portable
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c heap_4.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: acmp.c clk.c crypto.c emac.c fmc.c gpio.c m480sys.c retarget.c uart.c
  group Third_Party/cJSON
    ../../../../ThirdParty/cJSON/: cJSON.c cJSON.h
  group Third_Party/CmBacktrace
    ../../../../ThirdParty/CmBacktrace/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
  group Third_Party/lwIP/api
    ../../../../ThirdParty/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Third_Party/lwIP/apps/altcp_tls
    ../../../../ThirdParty/lwip-2.1.2/src/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c altcp_tls_mbedtls_mem.h altcp_tls_mbedtls_structs.h
  group Third_Party/lwIP/apps/http
    ../../../../ThirdParty/lwip-2.1.2/src/apps/http/: altcp_proxyconnect.c cgi.c cgi.h fs.c fsdata.c fsdata.h http_client.c httpd.c httpd_structs.h post.c ssi.c ssi.h
  group Third_Party/lwIP/apps/mqtt
    ../../../../ThirdParty/lwip-2.1.2/src/apps/mqtt/: mqtt.c
  group Third_Party/lwIP/core
    ../../../../ThirdParty/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Third_Party/lwIP/core/ipv4
    ../../../../ThirdParty/lwip-2.1.2/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Third_Party/lwIP/core/ipv6
    ../../../../ThirdParty/lwip-2.1.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Third_Party/lwIP/netif
    ../../../../ThirdParty/lwip-2.1.2/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group Third_Party/lwIP/netif/ppp
    ../../../../ThirdParty/lwip-2.1.2/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group Third_Party/lwIP/netif/ppp/polarssl
    ../../../../ThirdParty/lwip-2.1.2/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group Third_Party/lwIP/port
    ../../lwIP/netif/: ethernetif.c m480_eth.c
    ../../lwIP/: sys_arch.c time_stamp.c
  group Third_Party/mbedTLS
    ../../../../ThirdParty/mbedtls-2.13.0/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bigdigits.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group User
    ../: contiki_list.c contiki_list.h crc32.c crc32.h FreeRTOSConfig.h hex.c hex.h httpserver-socket.c httpserver-socket.h index.c lwipopts.h lwippools.h main.c mbedtls.h mbedtls_config.h minijson.c minijson.h mqtt_example.c mqtt_example.h netconf.c netconf.h networktask.c networktask.h pragma.c pragma.h searchdevice.c searchdevice.h tcp_echoserver-netconn.c tcp_echoserver-netconn.h tcpclient.c tcpclient.h tcpserver.c tcpserver.h uart_stream.c uart_stream.h udpserverandclient.c udpserverandclient.h
